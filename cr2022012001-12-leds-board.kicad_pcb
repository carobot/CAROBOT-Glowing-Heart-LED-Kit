# Repository carobot/CAROBOT-Glowing-Heart-LED-Kit

File README.md:

# CAROBOT Glowing Heart LED Kit

This repo contains the example code and the source files for the [CAROBOT Glowing Heart LED Kit](https://www.canadarobotix.com/products/2870).

## Example Code

[Example Arduino Code](https://github.com/carobot/CAROBOT-Glowing-Heart-LED-Kit/tree/main/carobot-glowing-heart)

## Circuit

The LED matrix circuit at a glance.

The board is designed to work with an [ATtiny85](https://www.canadarobotix.com/products/2770) which will be included in an upgraded version of the kit.

## KiCad design cr2022012001-12-leds-board.kicad_pcb

Parts:
BT1: Battery_Cell; BatteryHolder_Keystone_3002_1x2032
D1, D2, D3, D7, D8, D9, D13, D14, D15, D19, D20, D21: LED; LED_D10.0mm
D4, D5, D6, D10, D11, D12, D16, D17, D18, D22, D23, D24: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D25, D26: 3V6; D_SOD-323_HandSoldering
D27, D28: 3V6; D_DO-41_SOD81_P7.62mm_Horizontal
J1: USB_B_Micro; USB_Micro-B_Amphenol_10118194_Horizontal
J2: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J3: AVR-ISP-6; PinSocket_2x03_P2.54mm_Vertical
R1, R2, R3, R4: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6, R7: 47; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8, R9, R10, R11: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R14: 47; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Push; SW_PUSH_6mm
U1: ATtiny85-20PU; DIP-8_W7.62mm
U2: ATtiny85-20SU; SOIJ-8_5.3x5.3mm_P1.27mm

Connections:
GND: BT1.2 (-), D25.2 (A), D26.2 (A), D27.2 (A), D28.2 (A), J1.5 (GND), J3.6, SW1.1, U1.4 (GND), U2.4
unnamed: D1.1 (K), D4.1 (K), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D14.1 (K), D17.1 (K), D20.1 (K), D23.1 (K), R2.1, R9.1
unnamed: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.1 (K), D10.1 (K), D13.1 (K), D16.1 (K), D19.1 (K), D22.1 (K), R1.1, R8.1
unnamed: D2.1 (K), D5.1 (K), D8.1 (K), D11.1 (K), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D17.2 (A), D18.2 (A), D21.1 (K), D24.1 (K), R3.1, R10.1
unnamed: D3.1 (K), D6.1 (K), D9.1 (K), D12.1 (K), D15.1 (K), D18.1 (K), D19.2 (A), D20.2 (A), D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), R4.1, R11.1
unnamed: D25.1 (K), D27.1 (K), J1.2 (D-), R5.1, R6.2, R12.1, R13.2
unnamed: D26.1 (K), D28.1 (K), J1.3 (D+), R7.1, R14.1
unnamed: J2.1, J3.4, R1.2, R8.2, U1.5 (AREF/PB0), U2.5
unnamed: J2.2, J3.1, R2.2, R9.2, U1.6 (PB1), U2.6
unnamed: J2.3, J3.3, R3.2, R10.2, U1.7 (PB2), U2.7
unnamed: J2.4, R4.2, R7.2, R11.2, R14.2, U1.3 (XTAL2/PB4), U2.3
unnamed: J3.5, SW1.2, U1.1 (~RESET~/PB5), U2.1
unnamed: R6.1, R13.1, U1.2 (XTAL1/PB3), U2.2
VCC: BT1.1 (+), J1.1 (VBUS), J3.2, R5.2, R12.2, U1.8 (VCC), U2.8

Board: 2 copper layers, 68.0 x 68.0 mm, 49 parts (16 on the bottom side), 14 nets.

## Commit log

2022-01-20 Configure SAST in `.gitlab-ci.yml`, creating this file if it does not already exist
2022-01-20 Initial drawing
2022-01-21 updated drawing
2022-01-21 revNC
2022-02-07 added led circuit figure
2022-02-07 updated README and changed some file name
2022-03-12 updated code to work with ATtiny85
